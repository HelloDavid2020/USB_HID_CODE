# Keil uVision project MyUSB_HID_Test2.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MyUSB_HID_Test2 +hex
  c flags: Optim=1
  c include: .\FWLib\library\inc;.\Include;.\USB_library\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./Source/: cortexm3_macro.s stm32f10x_vector.s
  group User
    ./Source/: main.c stm32f10x_it.c hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group FWLib
    ./FWLib/library/src/: stm32f10x_gpio.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_exti.c
  group USBLib
    ./USB_library/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group Doc
    ./: ReadMe.txt
