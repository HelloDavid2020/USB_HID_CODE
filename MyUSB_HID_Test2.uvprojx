# Keil uVision project MyUSB_HID_Test2.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MyUSB_HID_Test2 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\FWLib\library\inc;.\Include;.\USB_library\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./Source/: cortexm3_macro.s stm32f10x_vector.s
  group User
    ./Source/: main.c stm32f10x_it.c hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group FWLib
    ./FWLib/library/src/: stm32f10x_gpio.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_exti.c
  group USBLib
    ./USB_library/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group Doc
    ./: ReadMe.txt
